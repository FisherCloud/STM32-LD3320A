# Keil uVision project STM32-LD3320.uvprojx, settings and files
target STM32-LD3320 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-LD3320 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\user;..\Libraries;..\Libraries\CMSIS;..\Libraries\CMSIS\CM3;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\BSP\LD_Driver;..\BSP\usart;..\BSP\delay;..\BSP\dma;..\BSP\timer;..\BSP\usb_user;..\BSP\sd_card;..\FATFS;..\FATFS\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../user/: main.c stm32f10x_it.c
  group BSP
    ../BSP/LD_Driver/: LD3320_main.c LDChip.c Reg_RW.c
    ../BSP/usart/: usart.c usart2.c
    ../BSP/delay/: delay.c
    ../BSP/dma/: dma.c
    ../BSP/timer/: timer.c
    ../BSP/sd_card/: sdio_sdcard.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_dma.c
  group USB_FS_Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_User
    ../BSP/usb_user/: hw_config.c mass_mal.c memory.c msd.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group FATFS
    ../FATFS/: diskio.c fatfs_posix.c ff.c
    ../FATFS/option/: cc936.c
  group other
    ../user/: LEDtest.C
software components: CMSIS:CORE 5.1.2
